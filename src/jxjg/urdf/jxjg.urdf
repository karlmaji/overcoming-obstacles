Commit message: 2023-7-30

File: src/jxjg/urdf/jxjg.urdf (robot description, URDF)
Before this commit: robot jxjg, 2 links, 1 joints
Links:
- link base: mass 272.3 -> 179.951906828969
Joints:
- joint joint1: origin xyz=0.32 0 0 rpy=-1.5708 0 -1.5708 -> xyz=-0.32 0 0 rpy=1.5708 0 0
